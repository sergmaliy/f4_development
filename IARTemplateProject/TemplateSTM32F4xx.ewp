# IAR project TemplateSTM32F4xx.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: CMSIS; StdPeriphLib\src; StdPeriphLib\inc; FatFS_0.09; FreeRTOS_7.4.0; FreeRTOS_7.4.0\include; FreeRTOS_7.4.0\portable; startup; User
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: TemplateSTM32F4xx.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: stm32f407xG.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    ./: main.c
    startup/: startup_stm32f4xx.s
  group CMSIS
    CMSIS/: system_stm32f4xx.c
  group FatFS
    FatFS_0.09/option/: ccsbcs.c
    FatFS_0.09/: diskio.c ff.c
  group FreeRTOS
    FreeRTOS_7.4.0/: croutine.c heap_2.c list.c queue.c tasks.c timers.c
  group STDPeriphLib
    StdPeriphLib/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group User
    User/: sdcard.c stm32f4xx_it.c usart.c
